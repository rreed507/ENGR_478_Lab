# Keil uVision project toggle_timer_interrupt_TivaWare.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: toggle_timer_interrupt_TivaWare
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --c99
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S toggle_timer_interrupt_TivaWare.c toggle_timer_interrupt_TivaWare.h switch_counter_interrupt_TivaWare.h
    ../../../../driverlib/rvmdk/: driverlib.lib
